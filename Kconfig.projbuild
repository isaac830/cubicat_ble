## Kconfig.projbuild
```kconfig
menu "Cubicat BLE Configuration"
	config BLE_DEBUG
		bool "Enable debug log"
		default n
		help
			Enable debug log
endmenu
```
